Commit message: synchronization

File: install/duo_description/share/duo_description/duo_robot.urdf (robot description, URDF)
Before this commit: robot duo, 7 links, 6 joints
Links:
- link caster_wheel: geometry collision cylinder length=0.02 radius=0.05; visual cylinder length=0.02 radius=0.05
